# Keil uVision project Lwatch.uvprojx, settings and files
target Lwatch (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Lwatch +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../driver;../Module;../bsp/stm32f411ceu6/driver;../bsp/stm32f411ceu6/system;../Module/sw_iic;../user;../bsp/peripheral_reg;../Lib/dmp;../user/task;..\Module\mserial;..\Module\mring_buffer;..\Module\niming
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c iwdg.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Module
    ../Module/mlist/: mlist.c
    ../Module/mpwm/: mpwm.c
    ../Module/sw_iic/: sw_iic.c
    ../Module/mserial/: mserial.c
    ../Module/mring_buffer/: mring_buffer.c
    ../Module/niming/: niming.c
  group driver
    ../driver/: drv_base.c drv_board.c drv_lcd.c drv_template.c drv_lcd_touch.c drv_mpu6050.c drv_serial.c drv_spl06.c
  group bsp/stm32f411ceu6/driver
    ../bsp/stm32f411ceu6/driver/: stm32f411ceu6_board.c stm32f411ceu6_lcd.c stm32f411ceu6_lcd_touch.c stm32f411ceu6_mpu6050.c stm32f411ceu6_serial.c stm32f411ceu6_spl06.c
  group bsp/stm32f411ceu6/system
    ../bsp/stm32f411ceu6/system/: delay.c
  group user/app
    ../user/: app.c freertos.c mpu6050_app.c spl06_app.c
  group lib/dmp
    ../Lib/dmp/: inv_mpu.c inv_mpu_dmp_motion_driver.c port_mpu.c
  group user/task
    ../user/task/: init_task.c
software components: CMSIS:CORE 4.3.0
